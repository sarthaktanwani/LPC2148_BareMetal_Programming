# Keil uVision project TestProject.uvproj, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: LPC2148 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: TestProject
  c flags: Optim=1 v6Lang=1 v6LangP=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./TestProject/: main.c
    ./74HC595/: delay.h
