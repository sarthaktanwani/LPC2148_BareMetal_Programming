# Keil uVision project OCFreaks.com_LPC214x_TimerIRQ_Tutorial.uvproj, settings and files
target OCFreaks.com_LPC214x_TimerIRQ_Tutorial (ARM-ADS)
  device: LPC2148 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: OCFreaks.com_LPC214x_TimerIRQ_Tutorial +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source
    ./: Startup.s main.cpp
